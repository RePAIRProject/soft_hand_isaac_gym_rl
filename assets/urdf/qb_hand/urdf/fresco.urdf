Commit message: update code of rl qbhand_grasp

File: assets/urdf/qb_hand/urdf/fresco.urdf (robot description, URDF)
Before this commit: robot fresco, 1 links, 0 joints
Links:
- link fresco: mass 0.068 -> 0.130
